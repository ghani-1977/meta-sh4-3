IMAGE_INSTALL_remove_sh4 += "\
	wscan \
	"
