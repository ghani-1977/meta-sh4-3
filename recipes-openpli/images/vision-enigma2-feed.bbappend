OPTIONAL_PACKAGES_remove_sh4 += "\
	dvb-apps \
	wscan \
	gdb \
	nodejs \
	smbnetfs \
	"
