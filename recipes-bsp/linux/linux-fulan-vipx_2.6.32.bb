require linux-fulan.inc

COMPATIBLE_MACHINE = "vip1_v2|vip2_v1"

STXNUMBER = "stx7109"