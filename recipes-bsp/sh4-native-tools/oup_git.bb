DESCRIPTION = "SH4 Opticum update program"

require sh4-native-tools.inc
