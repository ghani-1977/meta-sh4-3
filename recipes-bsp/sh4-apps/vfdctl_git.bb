DESCRIPTION = "VFD controller for SH4"

require sh4-apps.inc
