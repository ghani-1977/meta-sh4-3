DESCRIPTION = "SH4 tool to read MAC address"

require sh4-apps.inc
