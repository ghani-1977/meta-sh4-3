DESCRIPTION = "Streamproxy for live and file streaming and transcoding"

require sh4-apps.inc
