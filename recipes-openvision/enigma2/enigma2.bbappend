PV_sh4 = "sh4+git${SRCPV}"
PKGV_sh4 = "sh4+git${GITPKGV}"

SRC_URI_sh4 = "git://github.com/OpenVisionE2/enigma2-openvision-sh4.git;branch=${ENIGMA2_BRANCH}"
