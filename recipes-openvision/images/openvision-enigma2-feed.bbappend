OPTIONAL_PACKAGES_remove_sh4 += "\
	gdb \
	lirc \
	nodejs \
	smbnetfs \
	rtl8189es \
	rtl8812au \
	rtl8814au \
	rtl8822bu \
	"
