CXXFLAGS_append_sh4 += " -std=c++11 -fPIC -fno-strict-aliasing "
EXTRA_OECONF += " --disable-instrumentation "
